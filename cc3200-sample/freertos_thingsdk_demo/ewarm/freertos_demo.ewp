# IAR project freertos_demo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; KII_PUSH_KEEP_ALIVE_INTERVAL_SECONDS=60; KII_JSON_FIXED_TOKEN_NUM=30; KII_SERVER_PORT=80
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib; ../thing-if-ThingSDK; ../thing-if-ThingSDK/kii/kii; ../thing-if-ThingSDK/kii/kii-core; ../thing-if-ThingSDK/kii/kii_json/include; ../thing-if-ThingSDK/kii/kii_json/libs/jsmn
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c pinmux.c
    ../../common/: network_common.c startup_ewarm.c uart_if.c udma_if.c
    $EW_DIR$/arm/src/lib/: write.c
  group thing-if-ThingSDK
    ../thing-if-ThingSDK/: kii_thing_if.c
    ../: kii_thing_if_environment_cc3200.c
  group thing-if-ThingSDK/kii
    ../thing-if-ThingSDK/kii/kii/: kii_call.c kii_json_utils.c kii_mqtt.c kii_object.c kii_push.c kii_server_code.c kii_thing.c
  group thing-if-ThingSDK/kii/kii-core
    ../thing-if-ThingSDK/kii/kii-core/: kii_core.c kii_libc_wrapper.c
  group thing-if-ThingSDK/kii/kii-json
    ../thing-if-ThingSDK/kii/kii_json/libs/jsmn/: jsmn.c
    ../thing-if-ThingSDK/kii/kii_json/src/: kii_json.c
